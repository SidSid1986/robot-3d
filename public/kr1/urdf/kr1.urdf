Commit message: kr1

File: public/kr1/urdf/kr1.urdf (robot description, URDF)
Before this commit: robot kr1, 7 links, 6 joints
Joints:
- joint joint1: origin xyz=0 0 0.2452 rpy=0 0 0 -> xyz=0 0 0.2452 rpy=0 0 3.1416
